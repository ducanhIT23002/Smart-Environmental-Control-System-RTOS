# Keil uVision project Green_House_ConTrol_System.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pump_menu +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:Graphic LCD 1.0.0, Board Support:Joystick 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:SPI:SPI 2.3.0, CMSIS Driver:SPI:SSP 2.10.0, Device:GPDMA 1.4.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
